# Keil uVision project testPin-C011F6.uvprojx, settings and files
target testPin-C011F6 (6190000::V6.19::ARMCLANG)
  device: STM32C011F6Ux STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: testPin-C011F6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C011xx, TRACE_UART = 1
  c include: ../Core/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32c011xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_adc.c stm32c0xx_hal_adc_ex.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_cortex.c stm32c0xx_hal_exti.c stm32c0xx_hal_i2c.c stm32c0xx_hal_i2c_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
  group Drivers/VL503x
    ../Drivers/VL503x/: uart_trace.c vl53l0x_api.c vl53l0x_api.h vl53l0x_api_calibration.c vl53l0x_api_calibration.h vl53l0x_api_core.c vl53l0x_api_core.h vl53l0x_api_ranging.c vl53l0x_api_ranging.h vl53l0x_api_strings.c vl53l0x_api_strings.h vl53l0x_def.h vl53l0x_device.h vl53l0x_interrupt_threshold_settings.h vl53l0x_platform_log.c vl53l0x_platform_log.h vl53l0x_tuning.h vl53l0x_types.h vl53l0x_platform.c vl53l0x_platform.h
software components: CMSIS:CORE 4.3.0
